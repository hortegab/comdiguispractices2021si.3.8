options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    run: run_stop
  states: {}

blocks:
- name: Rb
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Retardo
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Retardo en el canal
    rangeType: int
    start: '0'
    step: '1'
    stop: '20'
    value: '0'
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Inicial/Parar
    'true': 'True'
    type: real
    value: 'True'
  states: {}
- name: b_bipolar_to_unipolar_ff_0
  id: b_bipolar_to_unipolar_ff
  parameters: {}
  states: {}
- name: b_unipolar2bipolar_ff_0
  id: b_unipolar2bipolar_ff
  parameters: {}
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/radiogis_director/MisGits/comdiguispractices2021si.3.8/unit I/Pract1.basic system based in rectangular pulse form/recibidoooooo.jpg
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/radiogis_director/MisGits/comdiguispractices2021si.3.8/unit I/Pract1.basic system based in rectangular pulse form/enviado.jpg
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: PCM
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: Mensaje
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: Pre-pre-canal
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,0,1,2
    label1: in  T2
    label2: in R2
    marker1: '0'
    marker2: '0'
    name: '"Binary signal"'
    nconnections: '2'
    size: '64'
    srate: Rb
    stemplot: 'True'
    type: float
    width1: '3'
    width2: '3'
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,1,2
    label1: 'in  T1 '
    label2: in  R1
    marker1: '0'
    marker2: '0'
    name: '"Source Signal"'
    nconnections: '2'
    size: int(64/8)
    srate: Rb/8
    type: float
    width1: '3'
    width2: '3'
    ymax: '128'
    ymin: '-128'
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: T2
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R2
  states: {}
- name: virtual_sink_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R1
  states: {}
- name: virtual_sink_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: T1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: T2
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: R2
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: R1
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: T1
  states: {}

connections:
- [b_bipolar_to_unipolar_ff_0, '0', blocks_float_to_char_0, '0']
- [b_unipolar2bipolar_ff_0, '0', b_bipolar_to_unipolar_ff_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_1, '0', b_unipolar2bipolar_ff_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_file_source_0, '0', virtual_sink_0_0_0_1, '0']
- [blocks_float_to_char_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_float_to_char_0, '0', virtual_sink_0_0_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_pack_k_bits_bb_0, '0', virtual_sink_0_0_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_0_0_0, '0']
- [virtual_source_0, '0', blocks_char_to_float_0, '0']
- [virtual_source_0_0, '0', blocks_char_to_float_0_0, '0']
- [virtual_source_0_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [virtual_source_0_1, '0', blocks_char_to_float_0_1, '0']

metadata:
  file_format: 1
